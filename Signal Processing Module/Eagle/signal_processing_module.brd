# Repository kiyu-git/Plant-Bioelectric-Potential-Sensor

File README.md:

[日本語](https://github.com/kiyu-git/Plant-Bioelectric-Potential-Sensor) | [English](/README-en.md)

# Plant Bioelectric Potential Sensor

植物生体電位測定器

## Overview

開発した植物生体電位測定器の回路図等をまとめています。

なお、このリポジトリは、『[植物生体電位測定をオープンにするプロジェクト](https://open-plant-bioelectric-potential-measurement.vercel.app)』の一部です。

[こちら](https://kiyu-shop.booth.pm)からプロジェクトへの寄付、PCB 基板およびパーツのセットの購入ができます。

## Revision history

### v1.0.0

- 最初のモデル

### v1.1.0

- 部品の番号を振り直し
- [リンク](https://github.com/kiyu-git/Plant-Bioelectric-Potential-Sensor/tree/1f7dd3a86559b1f9ea93b5415610122e70b9b8db)

### v1.1.1

- 信号処理モジュール
  - 回路図を清書
  - 一部の抵抗の値を変更

### v2.0

- Arduino シールド規格に合わせ、拡張性を高めた。
- 回路構成の大幅な変更をおこなった。

### v2.1

- DC-DC コンバータを MAU 106 から MAU108 に変更
  - Arduino の ADC のフルレンジ（0 - 5V）での測定が可能になった。

## Requirement

植物生体電位測定器の組み立てに必要な部品一覧

**測定基板**

回路図から読み取ってください

**測定用ケーブル**

| Device Name              | Value / Type | Need | Note                              |
| ------------------------ | ------------ | ---- | --------------------------------- |
| ユーロブロックターミナル |              | 1    |                                   |
| 導線                     | ~ 50cm       | 3    | 赤青黒の 3 色があるとわかりやすい |
| みの虫クリップ           | small        | 3    | 赤青黒の 3 色があるとわかりやすい |
| 釘                       |              | 1    | 導電性のもの                      |
| 電極パッド               |              | 2    | 心電パッドなどを流用              |

## Usage

このリポジトリは、『[植物生体電位測定をオープンにするプロジェクト](https://open-plant-bioelectric-potential-measurement.vercel.app)』の一部です。

[植物生体電位測定の例 (YouTube)](https://www.youtube.com/embed/kBemMpVNFAs?si=k8SLGgCpc5z7__u_)

## Reference

- Forest Symphony: [https://special.ycam.jp/interlab/projects/forestsymphony.html](https://special.ycam.jp/interlab/projects/forestsymphony.html)
- LT1167 DataSheet: https://www.analog.com/media/en/technical-documentation/data-sheets/1167fc.pdf
- [and more...](https://docs.google.com/presentation/d/1Tm0e-mBNrTchN6YlGpvvomUZfy79yOtrTSNHG-l_jFg/edit#slide=id.g148acf8fd66_1_54)

## Donation

[こちら](https://kiyu-shop.booth.pm/items/4141049)からプロジェクトへの寄付ができます。

## Author

質問等は twitter または[Issues](https://github.com/kiyu-git/Plant-Bioelectric-Potential-Sensor/issues)より

twitter: https://twitter.com/kyu_yukirinrin

website: https://untamable.work

## License

[GPL-3.0 license](https://github.com/kiyu-git/Plant-Bioelectric-Potential-Sensor/blob/main/LICENSE)

※ 共同研究や、案件依頼・相談も受け付けております。twitter DM または website よりご連絡ください。

## EAGLE design Signal Processing Module/Eagle/signal_processing_module.brd

Parts:
C1, C4, C5: 0.1u; C025-024X044
C2, C3: 47p; C025-024X044
IC1: LM324N; DIL14
IC2: TL061P; DIL08
JP1: PINHD-1X5; 1X05
LED: LED3MM
R1: 50k; RS3
R2, R4, R5, R8, R10, R11, R13: 10k; 0204/7
R3, R9, R12: 1k; 0204/7
R6, R14: 100k; 0204/7
R7: 68k; 0204/7
R15: 4.7k; 0204/7
R16: 50k; 2CH_VR
U$1: MJ-354W-SG-NEW; MJ-354W-SG

Connections:
+5V: C1.2, IC1.4 (V+), IC2.7 (V+), JP1.3
-5V: C5.1, IC1.11 (V-), IC2.4 (V-), JP1.4, R15.2
GND: C1.1, C2.2, C3.2, C4.2, C5.2, IC1.10 (+IN), IC1.12 (+IN), IC2.5 (ON2), JP1.5, LED.K (C), R13.1, R16.P$4, R16.P$5, U$1.P$1; also elsewhere on the board
unnamed: R9.1, U$1.P$2
unnamed: R3.1, U$1.P$4
unnamed: C2.1, IC2.3 (+IN), R3.2
unnamed: C3.1, IC2.2 (-IN), R9.2
unnamed: IC2.8 (OPT), R1.E, R1.S
unnamed: IC2.6 (OUT), R5.1
unnamed: IC2.1 (ON1), R1.A
unnamed: R6.2, R7.1
unnamed: IC1.13 (-IN), R8.1, R11.2
unnamed 12: LED.A, R15.1; also elsewhere on the board
unnamed: IC1.6 (-IN), R14.1, R16.P$6
unnamed: IC1.8 (OUT), R4.2, R11.1
unnamed: IC1.14 (OUT), R8.2, R12.1
unnamed: C4.1, IC1.5 (+IN), R7.2
unnamed: IC1.1 (OUT), IC1.2 (-IN), R2.1
unnamed: IC1.9 (-IN), R2.2, R4.1, R10.2
OUT: JP1.1, R12.2
RAW_SIGNAL: IC1.7 (OUT), R10.1, R14.2
SIGNAL: R5.2, R6.1, R13.2
VCC: IC1.3 (+IN), JP1.2

Notes on the sheet:
G = 1 + 49.4k / R_s R_s : 49.4k → G = 2 → out = *1 R_s : 49.4 → G = 1k → out = *500
LPF fc = 1 / (2πRC) 9.47Hz
R_f
RFノイズの除去
非反転増幅 G = 1 + (R_3 / V_r) V_r: 100K → G = 2
ボルテージフォロワ
反転可算回路 → 反転回路
MJ-354W-SG
LT1167

Board: 2 copper layers, 63.5 x 48.3 mm, 26 parts (0 on the bottom side), 23 nets.

Other parts of the board:
LED+: LED3MM

Their connections:
GND: LED+.K; also elsewhere on the board
unnamed 12: LED+.A; also elsewhere on the board

## EAGLE design Power and ADC Module/Eagle/power_adc_module.brd

Parts:
C1, C3, C4: 47u; E2,5-5
C2, C5: 0.1u; C025-024X044
DC1: IN 5v / OUT ±5v; NMA
JP1: PINHD-1X5; 1X05
JP2, JP3: PINHD-1X15; 1X15
MODUL: ARDUINO_NANO2
R1, R2: 10k; 0204/7

Connections:
+5V: C1.+, C2.1, DC1.6 (+VOUT), JP1.3, R1.1
-5V: C4.-, C5.2, DC1.4 (-VOUT), JP1.4
GND: C1.-, C2.2, C3.-, C4.+, C5.1, DC1.2 (-VIN), DC1.5 (COM), JP1.5, JP3.2, MODUL.J2.2 (COM), R2.1
IN5V: C3.+, DC1.1 (+VIN), JP3.4, MODUL.J2.4 (+5V)
unnamed: JP1.1, MODUL.J2.12 (A0)
unnamed: JP2.2, MODUL.J1.2 (D0/RX)
unnamed: JP2.1, MODUL.J1.1 (D1/TX)
unnamed: JP2.3, MODUL.J1.3 (RESET)
unnamed: JP2.4, MODUL.J1.4 (COM)
unnamed: JP2.5, MODUL.J1.5 (D2)
unnamed: JP2.6, MODUL.J1.6 (D3)
unnamed: JP2.7, MODUL.J1.7 (D4)
unnamed: JP2.8, MODUL.J1.8 (D5)
unnamed: JP2.9, MODUL.J1.9 (D6)
unnamed: JP2.10, MODUL.J1.10 (D7)
unnamed: JP2.11, MODUL.J1.11 (D8)
unnamed: JP2.12, MODUL.J1.12 (D9)
unnamed: JP2.13, MODUL.J1.13 (D10)
unnamed: JP2.14, MODUL.J1.14 (D11/MOSI)
unnamed: JP2.15, MODUL.J1.15 (D12/MISO)
unnamed: JP3.1, MODUL.J2.1 (VIN)
unnamed: JP3.3, MODUL.J2.3 (RESET)
unnamed: JP3.5, MODUL.J2.5 (A7)
unnamed: JP3.6, MODUL.J2.6 (A6)
unnamed: JP3.7, MODUL.J2.7 (A5)
unnamed: JP3.8, MODUL.J2.8 (A4)
unnamed: JP3.9, MODUL.J2.9 (A3)
unnamed: JP3.10, MODUL.J2.10 (A2)
unnamed: JP3.11, MODUL.J2.11 (A1)
unnamed: JP3.15, MODUL.J2.15 (D13/SCK)
unnamed: JP3.13, MODUL.J2.13 (AREF)
unnamed: JP3.14, MODUL.J2.14 (3V3)
VCC: JP1.2, R1.2, R2.2

Notes on the sheet:
1W 100mA

Board: 2 copper layers, 63.5 x 48.3 mm, 12 parts (0 on the bottom side), 33 nets.

## Commit log

2022-09-01 Add: LICENSE
2022-09-02 Add: Arduino sketch
2022-09-02 Update: README
2022-09-02 Add: CAM file and circuit img
2022-09-02 Add: images
2022-09-05 Add: old files
2022-09-05 Add: README 旧部品番号リストを追加
2022-09-05 Update: README 基板のバージョンに対応
2022-09-05 Update: リネーム
2022-09-05 Update README 文章を修正
2022-09-05 Update: README 文章を修正
2022-09-05 Update: README リンクを修正
2022-09-05 Create LISENCE
2022-09-05 Update: README add LICENSE
2022-09-13 Update: パーツリスト
2022-11-27 Update: gitignore
2022-11-27 Move archive files
2022-11-27 Update: v1.1.0
2022-11-27 Add: Box data
2023-03-28 Add: 英語版READMEを追加
2023-03-28 Update: READMEを更新
2023-04-29 Update: ボーレートを9600に変更
2023-05-17 v1.1.1を更新
2023-05-24 Update: リンクを修正
2023-08-30 Update: R16の値を修正
2023-10-13 Update: v2.0
2023-11-06 Add: advanced example
2023-12-18 Update: 回路図を最新に更新
2025-01-26 Update: v2.1
2025-01-26 Update: 誤表記を修正
